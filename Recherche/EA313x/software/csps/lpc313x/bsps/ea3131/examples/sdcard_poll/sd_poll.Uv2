### uVision2 Project, (C) Keil Software
### Do not modify !

Target (sd_poll), 0x0004 // Tools: 'ARM-ADS'

Group (csp)
Group (bsp)
Group (main)
Group (lpc)

File 1,1,<..\..\..\..\source\lpc313x_wdt_driver.c><lpc313x_wdt_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_cgu_default.c><lpc313x_cgu_default.c>
File 1,1,<..\..\..\..\source\lpc313x_cgu_driver.c><lpc313x_cgu_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_dma_driver.c><lpc313x_dma_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_intc_driver.c><lpc313x_intc_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_spi_driver.c><lpc313x_spi_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_timer_driver.c><lpc313x_timer_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_uart_driver.c><lpc313x_uart_driver.c>
File 1,2,<..\..\..\..\source\lpc313x_vectors.s><lpc313x_vectors.s>
File 1,1,<..\..\..\..\source\lpc313x_evt_driver.c><lpc313x_evt_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_i2c_driver.c><lpc313x_i2c_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_mci_driver.c><lpc313x_mci_driver.c>
File 1,1,<..\..\..\..\source\lpc313x_nand_driver.c><lpc313x_nand_driver.c>
File 2,2,<..\..\startup\ea3131_startup_entry.s><ea3131_startup_entry.s>
File 2,1,<..\..\startup\ea3131_startup.c><ea3131_startup.c>
File 2,1,<..\..\source\ea3131_spinor.c><ea3131_spinor.c>
File 2,1,<..\..\source\ea3131_board.c><ea3131_board.c>
File 2,5,<..\..\include\ea3131_board.h><ea3131_board.h>
File 2,2,<..\..\startup\pad.s><pad.s>
File 3,1,<.\sd_main.c><sd_main.c>
File 3,1,<.\fat.c><fat.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_x6x13.c><lpc_x6x13.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_api.c><lpc_api.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_arm922t_cp15_driver.c><lpc_arm922t_cp15_driver.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_bmp.c><lpc_bmp.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_colors.c><lpc_colors.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_fat16.c><lpc_fat16.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_fat16_private.c><lpc_fat16_private.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_fonts.c><lpc_fonts.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_heap.c><lpc_heap.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_helvr10.c><lpc_helvr10.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_lbecc.c><lpc_lbecc.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_lcd_params.c><lpc_lcd_params.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_line_parser.c><lpc_line_parser.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_nandflash_params.c><lpc_nandflash_params.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_rom8x8.c><lpc_rom8x8.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_rom8x16.c><lpc_rom8x16.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_string.c><lpc_string.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_swim.c><lpc_swim.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_swim_font.c><lpc_swim_font.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_swim_image.c><lpc_swim_image.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_winfreesystem14x16.c><lpc_winfreesystem14x16.c>
File 4,1,<..\..\..\..\..\..\lpc\source\lpc_x5x7.c><lpc_x5x7.c>


Options 1,0,0  // Target 'sd_poll'
 Device (LPC3180)
 Vendor (NXP (founded by Philips))
 Cpu (IRAM(0x08000000-0x0800FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI))
 FlashUt ()
 StupF ("STARTUP\Philips\LPC3000.s" ("Philips LPC3000 Startup Code"))
 FlashDR ()
 DevID (4128)
 Rgf (LPC318x.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿPhilips\)
 OrgReg (ÿPhilips\)
 TgStat=16
 OutDir (.\output\)
 OutName (keil_example)
 GenApp=1
 GenLib=0
 GenHex=0
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 1 <fromelf.exe --output "$P\lpc313x.bin" --bin "$P/output/%L.axf">
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 ADSFLGA { 243,31,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACPUTYP (ARM926EJ-S)
 RVDEV ()
 ADSTFLGA { 0,204,0,2,99,0,0,66,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSOCM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSIRAM { 0,0,0,0,8,0,0,1,0 }
 OCMADSIROM { 1,0,0,0,0,0,64,0,0 }
 OCMADSXRAM { 0,0,0,0,0,0,0,0,0 }
 OCR_RVCT { 1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,64,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,144,2,17,0,240,2,0,0,0,0,0,0,0,0,0,0 }
 RV_STAVEC ()
 ADSCCFLG { 5,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSCMISC ()
 ADSCDEFN ()
 ADSCUDEF ()
 ADSCINCD (..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include)
 ADSASFLG { 1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSAMISC ()
 ADSADEFN ()
 ADSAUDEF ()
 ADSAINCD ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ADSLDFG { 16,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSLDTA (0x110290000)
 ADSLDDA (0x110400000)
 ADSLDSC (..\common\ldscript_iram_ads.ld)
 ADSLDIB ()
 ADSLDIC ()
 ADSLDMC ()
 ADSLDIF ()
 ADSLDDW ()
  OPTDL (SARM.DLL)(-cLPC3000)(DARMP3.DLL)(-pLPC3180)(SARM.DLL)()(TARMP3.DLL)()
  OPTDBG 47602,0,()()()()()()()()()(..\common\keil_init.ini) (BIN\UL2ARM.DLL)()()()
 FLASH1 { 2,0,0,0,1,0,0,0,0,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\UL2ARM.DLL)
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

