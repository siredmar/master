# Keil uVision project usbaudio.uvproj, settings and files
target usbaudio (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: usbaudio
  AfterMake: fromelf.exe --output "$P\output\usbaudio.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c define: DEBUG
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include;..\..\..\..\..\..\ip\usbd\include;.\
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csp
    ../../../../source/: lpc313x_usbdcd.c lpc31xx_vmem_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_dma_driver.c lpc313x_i2s_clock_driver.c lpc313x_i2s_driver.c lpc313x_intc_driver.c lpc313x_mstr_i2c_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c lpc3152_codec_driver.c lpc313x_vectors.s
  group lpc
    ../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_string.c
  group ip
    ../../../../../../ip/usbd/source/: usbcore.c adcuser.c
  group bsp
    ../../startup/: pad.s ea3152_startup.c ea3152_startup_entry.s
    ../../source/: ea3152_board.c
  group main
    ./: usbdesc.c dbg.c isohandler.c main.c pcmhandler.c
target usbaudio_cache (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: as above
  output: usbaudio_cache
  AfterMake: fromelf.exe --output "$P\output\usbaudio_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c define: DEBUG
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target usbaudio_sdram (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: as above
  output: usbaudio
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM DEBUG
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads.ld
target usbaudio_sdram_cache (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: as above
  output: usbaudio_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM DEBUG
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
