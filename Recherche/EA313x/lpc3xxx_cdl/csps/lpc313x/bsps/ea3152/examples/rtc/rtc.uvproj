# Keil uVision project rtc.uvproj, settings and files
target rtc (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: rtc
  AfterMake: fromelf.exe --output "$P\output\rtc.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csp
    ../../../../source/: lpc315x_rtc_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_evt_driver.c lpc313x_intc_driver.c lpc313x_mstr_i2c_driver.c lpc313x_uart_driver.c lpc313x_vectors.s lpc313x_timer_driver.c
  group bsp
    ../../startup/: pad.s ea3152_startup.c ea3152_startup_entry.s
    ../../source/: libnosys_gnu.c ea3152_board.c
  group main
    ./: rtc_example.c
  group lpc
    ../../../../../../lpc/source/: lpc_arm922t_cp15_driver.c
target rtc_cache (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: as above
  output: rtc_cache
  AfterMake: fromelf.exe --output "$P\output\rtc_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target rtc_sdram (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: as above
  output: rtc
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads.ld
target rtc_sdram_cache (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: as above
  output: rtc_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
