# Keil uVision project i2s_audio.uvproj, settings and files
target i2s_audio_sdram (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: i2s_audio
  AfterMake: fromelf.exe --output "$P\output\i2s_audio.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include;..\..\..\ea3152\include
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\..\..\ea3152\examples\common\ldscript_sdram_ads.ld
  group csp
    ../../../../source/: lpc3152_codec_driver.c lpc31xx_vmem_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_dma_driver.c lpc313x_evt_driver.c lpc313x_i2s_clock_driver.c lpc313x_i2s_driver.c lpc313x_intc_driver.c lpc313x_mstr_i2c_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c lpc313x_vectors.s
  group bsp
    ../../../ea3152/startup/: pad.s ea3152_startup.c ea3152_startup_entry.s
    ../../../ea3152/source/: libnosys_gnu.c ea3152_board.c
  group main
    ./: lpc_pacmanva.c i2s_audio_example.c
  group lpc
    ../../../../../../lpc/source/: lpc_x6x13.c lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x8.c lpc_rom8x16.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_wave.c lpc_winfreesystem14x16.c lpc_x5x7.c
target i2s_audio_sdram_cache (ARM-ADS)
  device: LPC3152 NXP (founded by Philips)
  cpu: as above
  output: i2s_audio_cache
  AfterMake: fromelf.exe --output "$P\output\i2s_audio_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\..\..\ea3152\examples\common\ldscript_sdram_ads_cache.ld
