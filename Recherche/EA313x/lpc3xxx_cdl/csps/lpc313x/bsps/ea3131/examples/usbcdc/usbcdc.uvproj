# Keil uVision project usbcdc.uvproj, settings and files
target usbcdc (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: usbcdc
  AfterMake: fromelf.exe --output "$P\output\usbcdc.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include;..\..\..\..\..\..\ip\usbd\include;.\
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csps
    ../../../../source/: lpc313x_vectors.s lpc31xx_vmem_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_evt_driver.c lpc313x_intc_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c lpc313x_usbdcd.c
  group bsps
    ../../startup/: ea3131_startup.c ea3131_startup_entry.s pad.s
    ../../source/: ea3131_board.c
  group lpc
    ../../../../../../lpc/source/: lpc_string.c lpc_api.c lpc_arm922t_cp15_driver.c
  group ip
    ../../../../../../ip/usbd/source/: usbcore.c cdcuser.c
  group main
    ./: usbdesc.c main.c serial.c
target usbdcd_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: usbcdc_cache
  AfterMake: fromelf.exe --output "$P\output\usbcdc_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target usbcdc_sdram (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: usbcdc
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads.ld
target usbcdc_sdram_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: usbcdc_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
