# Keil uVision project sdcard_chanfat.uvproj, settings and files
target sdcard_chanfat (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: sdcard_chanfat
  AfterMake: fromelf.exe --output "$P\output\sdcard_chanfat.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include;..\..\..\..\..\..\ip\fatfs
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csp
    ../../../../source/: lpc313x_uart_driver.c lpc31xx_vmem_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_dma_driver.c lpc313x_evt_driver.c lpc313x_intc_driver.c lpc313x_mci_driver.c lpc313x_timer_driver.c lpc313x_vectors.s
  group bsp
    ../../startup/: pad.s ea3131_startup.c ea3131_startup_entry.s
    ../../source/: libnosys_gnu.c ea3131_board.c ea3131_mci.c
  group main
    ./: sd_main.c mmc.c
  group lpc
    ../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x8.c lpc_rom8x16.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_wave.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
  group ip
    ../../../../../../ip/fatfs/: ff.c
target sdcard_chanfat_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: sdcard_chanfat_cache
  AfterMake: fromelf.exe --output "$P\output\sdcard_chanfat_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target sdcard_chanfat_sdram (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: sdcard_chanfat
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads.ld
target sdcard_chanfat_sdram_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: sdcard_chanfat_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
