# Keil uVision project nand_perf.uvproj, settings and files
target nand_perf (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: nand_perf
  AfterMake: fromelf.exe --output "$P\output\nand_perf.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include;..\..\..\..\..\..\ip\fatfs
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x11029000 size 0x2f000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csp
    ../../../../source/: lpc313x_pwm_driver.c lpc313x_spi_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c lpc313x_wdt_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_crc_driver.c lpc313x_dma_driver.c lpc313x_evt_driver.c lpc313x_i2c_driver.c lpc313x_intc_driver.c lpc313x_mci_driver.c lpc313x_nand_driver.c lpc313x_vectors.s lpc31xx_vmem_driver.c
  group bsp
    ../../startup/: pad.s ea3131_startup.c ea3131_startup_entry.s
    ../../source/: ea3131_spinor.c ea3131_board.c
  group main
    ./: nand_perf.c
  group lpc
    ../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x8.c lpc_rom8x16.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
target nand_perf_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: nand_perf_cache
  AfterMake: fromelf.exe --output "$P\output\nand_perf_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x11029000 size 0x2f000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target nand_perf_sdram (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: nand_perf
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x11029000 size 0x2f000
  scatter file: ..\common\ldscript_sdram_ads.ld
target nand_perf_sdram_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: nand_perf_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x11029000 size 0x2f000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
