# Keil uVision project pca9532_i2c_example.uvproj, settings and files
target I2C (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: pca9532_i2c
  AfterMake: fromelf.exe --output "$P\output\pca9532_i2c.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group LPC
    ../../../../../../lpc/source/: lpc_arm922t_cp15_driver.c
  group CSP
    ../../../../source/: lpc313x_timer_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_i2c_driver.c lpc313x_intc_driver.c lpc313x_vectors.s
  group BSP
    ../../source/: ea3131_board.c lpc313x_pca9532_driver.c
    ../../startup/: pad.s ea3131_startup.c ea3131_startup_entry.s
  group app
    ./: pca9532_i2c_example.c
target I2C_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: pca9532_i2c_cache
  AfterMake: fromelf.exe --output "$P\output\pca9532_i2c_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target I2C_SDRAM (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: pca9532_i2c
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads.ld
target I2C_SDRAM_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: pca9532_i2c_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
