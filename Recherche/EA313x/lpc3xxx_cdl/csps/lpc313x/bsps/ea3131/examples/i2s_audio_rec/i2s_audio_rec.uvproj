# Keil uVision project i2s_audio_rec.uvproj, settings and files
target i2s_audio_rec (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: i2s_audio_rec
  AfterMake: fromelf.exe --output "$P\output\i2s_audio_rec.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csps
    ../../../../source/: lpc313x_vectors.s lpc31xx_vmem_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_dma_driver.c lpc313x_i2s_clock_driver.c lpc313x_i2s_driver.c lpc313x_intc_driver.c lpc313x_mstr_i2c_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c
  group bsps
    ../../startup/: pad.s ea3131_startup.c ea3131_startup_entry.s
    ../../source/: uda1380_codec_driver.c ea3131_board.c lpc313x_debug.c
  group lpc
    ../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c
  group main
    ./: i2s_audio_example.c
target i2s_audio_rec_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: i2s_audio_rec_cache
  AfterMake: fromelf.exe --output "$P\output\i2s_audio_rec_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include;.\;.\clk
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target i2s_audio_rec_sdram (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: i2s_audio_rec
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads.ld
target i2s_audio_rec_sdram_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: i2s_audio_rec_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
