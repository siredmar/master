# Keil uVision project sram_timing.uvproj, settings and files
target sram_timing (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: sram_timing
  AfterMake: fromelf.exe --output "$P\output\sram_timing.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\..\..\..\..\lpc\include;..\..\..\..\include;..\..\include;..\..\..\..\..\..\ip\usbd\include;.\
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csp
    ../../../../source/: lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_vectors.s lpc313x_intc_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c lpc313x_usbdcd.c lpc31xx_vmem_driver.c lpc313x_dma_driver.c lpc313x_evt_driver.c lpc313x_pwm_driver.c
  group bsp
    ../../startup/: ea3131_startup_entry.s pad.s ea3131_startup.c
    ../../source/: libnosys_gnu.c ea3131_board.c ea3131_lcd.c
  group lpc
    ../../../../../../lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_string.c
  group main
    ./: usbdesc.c sram_timing.c usb_test.c
  group ip
    ../../../../../../ip/usbd/source/: usbcore.c
target sram_timing_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: sram_timing_cache
  AfterMake: fromelf.exe --output "$P\output\sram_timing_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
