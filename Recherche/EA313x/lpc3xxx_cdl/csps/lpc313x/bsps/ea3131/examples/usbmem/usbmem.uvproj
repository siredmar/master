# Keil uVision project usbmem.uvproj, settings and files
target usbmem (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: IRAM(0x11028000-0x1103FFFF) IRAM2(0x11040000-0x11057FFF) IROM(0x12000000-0x1201FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: usbmem
  AfterMake: fromelf.exe --output "$P\output\usbmem.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: ..\..\include;..\..\..\..\include;..\..\..\..\..\..\ip\usbd\include;..\..\..\..\..\..\lpc\include;..\usbmem;..\..\..\..\..\..\ip\fatfs
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads.ld
  group csp
    ../../../../source/: lpc3152_codec_driver.c lpc313x_adc10b_driver.c lpc313x_cgu_default.c lpc313x_cgu_driver.c lpc313x_crc_driver.c lpc313x_dma_driver.c lpc313x_evt_driver.c lpc313x_i2c_driver.c lpc313x_i2s_clock_driver.c lpc313x_i2s_driver.c lpc313x_intc_driver.c lpc313x_ipint_driver.c lpc313x_mci_driver.c lpc313x_mstr_i2c_driver.c lpc313x_nand_driver.c lpc313x_pwm_driver.c lpc313x_spi_driver.c lpc313x_timer_driver.c lpc313x_uart_driver.c lpc313x_usbdcd.c lpc313x_wdt_driver.c lpc315x_otp_driver.c lpc315x_psu_driver.c lpc315x_rtc_driver.c lpc313x_vectors.s lpc31xx_vmem_driver.c
  group bsp
    ../../source/: ea3131_board.c ea3131_spinor.c lpc313x_pca9532_driver.c uda1380_codec_driver.c
    ../../startup/: ea3131_startup.c ea3131_startup_entry.s pad.s
  group main
    ./: usbdesc.c main.c
  group lpc
    ../../../../../../lpc/source/: lpc_x6x13.c lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x8.c lpc_rom8x16.c lpc_string.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c
  group ip
    ../../../../../../ip/usbd/source/: usbcore.c mscuser.c
target usbmem_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: usbmem_cache
  AfterMake: fromelf.exe --output "$P\output\usbmem_cache.bin" --bin "$P\output\%L"
  c flags: Optim=3
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_iram_ads_cache.ld
target usbmem_sdram (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: usbmem
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads.ld
target usbmem_sdram_cache (ARM-ADS)
  device: LPC3131 NXP (founded by Philips)
  cpu: as above
  output: usbmem_cache
  AfterMake: as above
  c flags: Optim=3
  c define: TGT_SDRAM
  c include: as above
  memory RVCT4: ROM 0x12000000 size 0x20000
  memory RVCT9: RAM 0x11028000 size 0x18000
  memory RVCT10: RAM 0x11040000 size 0x18000
  scatter file: ..\common\ldscript_sdram_ads_cache.ld
